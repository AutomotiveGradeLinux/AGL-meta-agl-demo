IMAGE_INSTALL += " \
    v4h-domd-udev-input-rules \
"
