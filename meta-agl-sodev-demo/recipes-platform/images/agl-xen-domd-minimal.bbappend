require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-demo', 'agl-xen-domd-minimal_agl-sodev-demo.inc', '', d)}
