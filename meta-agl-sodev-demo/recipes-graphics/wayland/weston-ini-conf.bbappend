require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-demo', 'weston-ini-conf_agl-sodev-demo.inc', '', d)}
